# Repository EosinY/ElectronicLoad-AnalogControllerDIP

## KiCad design Main_DIP_Controller.kicad_pcb

Parts:
C1: 0.33u; C_Disc_D5.1mm_W3.2mm_P5.00mm
C3, C9, C11, C15: 0.1u; C_Disc_D5.1mm_W3.2mm_P5.00mm
C4, C6: 100u; CP_Radial_D5.0mm_P2.00mm
C7, C8: 0.01u; C_Disc_D5.1mm_W3.2mm_P5.00mm
D1: GS1010FL; D_DO-41_SOD81_P10.16mm_Horizontal
FL1: BNX016-01; EMI-Filter_4P_muRata-BNX
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
HS1: Heatsink_Pad_2Pin; Heatsink_16.5x16x25
J1: Switch_Control; JST_XH_B5B-XH-A_1x05_P2.50mm_Vertical
J2: 2.1-5.5 DC; BarrelJack_Horizontal1
J3: +5V; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J4: AnalogIO; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J5: +12V; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J6: VsensJMP; PinHeader_1x03_P2.54mm_Vertical
J7: Drain; ScrewTerminal_01x01_PCB-20
J8: Gate; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J9: Source; ScrewTerminal_01x01_PCB-20
J10: Vin_-; ScrewTerminal_01x01_PCB-20
J11: Conn_01x02; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J12: Vsens; ScrewTerminal_01x01_PCB-20
J13: Vin+; ScrewTerminal_01x01_PCB-20
P1: Eoshi-chan_Silk; Eoshi-chan_logo_10x10
Q1: 2N7000; TO-92_Inline; MPN 2N7000; Digi-Key_PN 2N7000FS-ND
R1, R2, R3, R4, R6: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R5, R10: 390k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R7: 100; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R8: 499; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R9: 2.61k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R11, R12: 20m; R_2512_6332Metric
RLY1: 943-1C-12DS; HSINDA-943_12A-1C_5p; MPN G5LE-14 DC5; Digi-Key_PN Z1011-ND
RV1: 10k; Potentiometer_Vishay_T73YP_Vertical
TH1: Thermistor; C_Disc_D3.0mm_W1.6mm_P2.50mm
U1: NJM7805FA; TO-220-3_Vertical
U2: TC74HC4066AF(F); DIP-14_W7.62mm_Socket
U3: AD8226ARZ; SOIC-8_3.9x4.9mm_P1.27mm
U4: S-89713B-K8T2U; MSOP-8_3x3mm_P0.65mm; MPN LM358N; Digi-Key_PN LM358NFS-ND

Connections:
+12V: C1.1, C6.1, D1.1 (K), FL1.2 (CB), J5.1, RLY1.5 (COIL), U1.1 (Vin)
/Load+: J6.3, J13.1, RLY1.3 (NO)
/MOS+: J7.1, RLY1.1 (COM)
/MOS-: J9.1, R11.1, R12.1, U3.4 (+)
/TH_1: J11.1, TH1.1
/TH_2: J11.2, TH1.2
/Vmeas: C7.1, J4.1, R5.1, U4.7
/Vmeas_IN: J6.2, R10.2
/Vref: J4.2, U4.2
/Vsens: J6.1, J12.1
GND: C1.2, C3.2, C4.2, C6.2, C9.2, C11.2, C15.2, FL1.4 (CG), J1.5, J3.2, J4.4, J5.2, J8.2, Q1.1 (S), R1.1, R2.1, R3.1, R4.1, U1.2 (GND), U2.7 (VSS), U2.12, U3.5 (Vs-), U4.4 (GND)
LOAD_ENABLE: D1.2 (A), Q1.3 (D), RLY1.2 (COIL)
Load-: J10.1, R6.1, R11.2, R12.2, RLY1.4 (NC), U3.1 (-)
unnamed: C7.2, R5.2, R6.2, R10.1, U4.6
unnamed: C8.1, RV1.1, RV1.2, U4.3
unnamed: C8.2, R7.1, U4.1
unnamed: FL1.1 (B), J2.1
unnamed: FL1.3 (PSG), J2.2
unnamed: J1.4, Q1.2 (G), R4.2
unnamed: J8.1, R7.2
unnamed: R8.1, U2.3
unnamed: R9.1, U2.2
unnamed: RV1.3, U2.9
unnamed: U2.8, U3.7
Rg_1: U2.1, U2.4, U3.2 (Rg)
Rg_2: R8.2, R9.2, U3.3 (Rg)
SHUNT_SELECT1: J1.2, R2.2, U2.5
SHUNT_SELECT2: J1.1, R1.2, U2.13
VCC: C3.1, C4.1, C9.1, C11.1, C15.1, J3.1, U1.3 (Vout), U2.14 (VDD), U3.8 (Vs+), U4.8 (VCC)
Vconst_ENABLE: J1.3, R3.2, U2.6
Vofs: J4.3, U3.6 (Ref), U4.5

Notes on the sheet:
OPアンプのパスコン
4066のパスコン
(Vofs+0)~(Vofs+2.048)V (Vofs=2)
0~80V
(Vofs+0)~(Vofs+2)V (Vofs=2)

Board: 4 copper layers, 50 parts (0 on the bottom side), 31 nets, no tracks yet.

## Commit log

2025-03-13 First
2025-03-13 Finish parts placement
